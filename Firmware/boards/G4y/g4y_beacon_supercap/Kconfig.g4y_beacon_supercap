## boards/G4y/g4y_beacon_supercap/Kconfig.defconfig
```kconfig
if BOARD_G4Y_BEACON_SUPERCAP

config BT_CTLR
	default BT

endif # BOARD_G4Y_BEACON_SUPERCAP
```
